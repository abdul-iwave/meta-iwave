FILESEXTRAPATHS_prepend := "${THISDIR}/weston:"

SRC_URI_append += "file://mipi_dsi_lcd_180_rotate_iwg37m.patch"
