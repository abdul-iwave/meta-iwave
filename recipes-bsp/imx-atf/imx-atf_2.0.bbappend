ATF_SRC = "git://github.com/abdul-iwave/imx-atf.git;protocol=https"
SRCBRANCH = "iwg37m-R1.0-REL0.1"
SRC_URI = "${ATF_SRC};branch=${SRCBRANCH}"
SRCREV = "395313e2bbc267f4dd8ee5e37b271a35881aba59" 
